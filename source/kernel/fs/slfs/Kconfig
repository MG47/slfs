## source/kernel/fs/slfs/Kconfig
```kconfig
#MG47
config SLFS_FS
	bool "SLFS file system support"
	default y
	help
	#TODO
	SLFS is a virtual filesystem
```
